## Kconfig
```kconfig
# Copyright (c) 2023 Chen Xingyu <hi@xingrz.me>
# SPDX-License-Identifier: Apache-2.0

config HISILICON
	bool "HiSilicon SoCs"
	help
	  Enable support for HiSilicon SoCs.
```
